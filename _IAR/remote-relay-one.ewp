# IAR project remote-relay-one.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x000
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\driver\beep; ..\driver\eeprom; ..\driver\led; ..\driver\remote; ..\driver\serial; ..\driver\timestamp; ..\driver\utils; ..\src; ..\STD\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: remote-relay-one.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group driver/beep
    ../driver/beep/: beep.c beep.h
  group driver/eeprom
    ../driver/eeprom/: eeprom.c eeprom.h
  group driver/led
    ../driver/led/: led.c led.h
  group driver/remote
    ../driver/remote/: remote-consts.h remote.c remote.h
  group driver/serial
    ../driver/serial/: serial.c serial.h
  group driver/timestamp
    ../driver/timestamp/: timestamp.c timestamp.h
  group driver/utils
    ../driver/utils/: utils.c utils.h
  group src
    ../src/: init.c init.h main.c main.h stm8s_conf.h stm8s_it.c stm8s_it.h store.c store.h
  group STD/inc
    ../STD/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_uart2.h stm8s_uart3.h stm8s_uart4.h stm8s_wwdg.h
  group STD/src
    ../STD/src/: stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_i2c.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
